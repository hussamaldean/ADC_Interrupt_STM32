# Keil uVision project ST7735 Bare Metal.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ST7735 Bare Metal
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: main.c
  group SPI
    ./: SPI.c SPI.h
  group Delay
    ./: delay.c delay.h
  group ST7735
    ./: GLCD_ST7735.c GLCD_ST7735.h
  group Internal Temperature
    ./: Temperature.c Temperature.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
